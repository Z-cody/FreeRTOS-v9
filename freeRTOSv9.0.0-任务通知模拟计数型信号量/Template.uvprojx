# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: .\RTE;.\RTE\Device\STM32F407ZE;.\FreeRTOS\include;.\FreeRTOS\portable\RVDS\ARM_CM4F;.\SYSTEM\DELAY;.\SYSTEM\SYS;.\HARDWARE\EXTI;.\HARDWARE\KEY;.\HARDWARE\LED;.\HARDWARE\PWM;.\HARDWARE\TIM;.\SYSTEM\UART;.\FreeRTOS\include;.\FreeRTOS\portable\RVDS\ARM_CM4F
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group FreeRTOS_CORE
    ./FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ./FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ./FreeRTOS/portable/MemMang/: heap_4.c
  group SYSTEM
    ./SYSTEM/DELAY/: delay.c
  group HARDWARE
    ./HARDWARE/EXTI/: exti.c
    ./HARDWARE/KEY/: key.c
    ./HARDWARE/LED/: led.c
    ./HARDWARE/PWM/: pwm.c
    ./HARDWARE/TIM/: tim.c
    ./SYSTEM/UART/: usart.c
  group USER
    ./USER/: main.c
software components: CMSIS:CORE 5.1.2, Device:Startup 1.3.1, Device:StdPeriph Drivers:EXTI 1.3.0, Device:StdPeriph Drivers:Framework 1.3.1, Device:StdPeriph Drivers:GPIO 1.3.0, Device:StdPeriph Drivers:RCC 1.3.0, Device:StdPeriph Drivers:SYSCFG 1.3.0, Device:StdPeriph Drivers:TIM 1.3.0, Device:StdPeriph Drivers:USART 1.3.0
